# Keil uVision project Pong.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../inc;..\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: osasm.s os.c ball.c ball.h game.h main.c paddle.c paddle.h walls.c walls.h comm_lib.c comm_lib.h
    ../inc/: BSP.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
